# Keil uVision project fdd_fw2.uvproj, settings and files
target CosmosEx (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fdd_fw2
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group FDD FW
    ./: startup_stm32f10x_ld.s main.c system_stm32f10x.c defs.h stm32f10x_tim.h timers.c timers.h stm32f10x_spi.c stm32f10x_spi.h misc.c misc.h
