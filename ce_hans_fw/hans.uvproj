# Keil uVision project hans.uvproj, settings and files
target CosmosEx (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: acsi_fw +hex
  c flags: Optim=4 oTime=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ACSI FW
    ./: defs.h main.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_tim.h timers.c timers.h stm32f10x_spi.c stm32f10x_spi.h misc.c misc.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_tim.c stm32f10x_exti.c stm32f10x_exti.h bridge.h bridge.c datatransfer.c datatransfer.h scsi.h scsi.c mmc.h mmc.c mmc_datatransfer.c eeprom.c eeprom.h stm32f10x_flash.c stm32f10x_flash.h cosmosolo.c cosmosolo.h
