# Keil uVision project fdd_fw2.uvproj, settings and files
target CosmosEx (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fdd_fw2 +hex
  c flags: Optim=4 oTime=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FDD FW
    ./: main.c system_stm32f10x.c defs.h stm32f10x_tim.h timers.c timers.h stm32f10x_spi.c stm32f10x_spi.h misc.c misc.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_tim.c stm32f10x_exti.c stm32f10x_exti.h main.h floppyhelpers.c floppyhelpers.h init.c init.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_rcc.h stm32f10x_rcc.c startup_stm32f10x_md.s
